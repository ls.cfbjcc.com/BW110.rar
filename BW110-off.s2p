!  2-Port S-parameters saved by WinCal
! VAR MeasName=S-Parameters (CALIBRATED_DATA) read from VNA (E8364A)
! VAR MeasDate=10/9/2010 2:18:46 PM
! VAR NAME=15(25)
! VAR FILENAME=15(25).s2p
! VAR DATE=10/9/2010 2:18:47 PM
! VAR PHYS_PORTS=1,2
# Hz S RI R 50
! Worked out from all points (weakly coupled two-port):
!   501 points, 45 MHz to 20 GHz, reference 50 ohm
!   highest |S21| = -37.79 dB at 20 GHz (marker M1); lowest = -76.7 dB at 7.668 GHz (marker M2)
!   lowest |S11| = -60.5 dB at 12.1 GHz (marker M3), VSWR 1.00, Z = 50.1 - j0.0143 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -73.0 to -22.7 dB; largest |S21 - S12| = 0.0011
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 45 MHz  -26.7  -60.1  -75.9  -26.7
! 164.7 MHz  -26.2  -71.6  -70.1  -26.3
! 883.1 MHz  -26.2  -63.3  -64.0  -26.2
! 2.759 GHz  -26.9  -67.0  -63.8  -26.7
! 3.397 GHz  -27.1  -66.0  -80.6  -26.7
! 6.71 GHz  -28.9  -74.4  -70.0  -28.9
! 7.668 GHz  -29.6  -76.7  -71.7  -29.5
! 10.02 GHz  -31.7  -62.9  -64.5  -32.3
! 12.1 GHz  -60.5  -55.9  -55.9  -40.4
! 12.54 GHz  -35.4  -55.7  -56.0  -39.6
! 12.82 GHz  -38.4  -53.6  -54.2  -56.8
! 13.06 GHz  -36.4  -53.7  -53.3  -43.3
! 13.37 GHz  -39.7  -52.7  -52.8  -48.9
! 13.61 GHz  -38.6  -51.6  -52.0  -47.6
! 13.77 GHz  -39.6  -51.9  -52.4  -73.0
! 14.05 GHz  -45.2  -50.9  -51.2  -40.9
! 14.33 GHz  -40.9  -50.5  -50.7  -49.4
! 14.61 GHz  -33.1  -49.5  -49.3  -37.6
! 14.97 GHz  -34.6  -49.1  -49.2  -42.8
! 15.25 GHz  -53.6  -48.4  -48.3  -34.3
! 16.69 GHz  -26.6  -44.7  -44.7  -30.5
! 20 GHz  -20.6  -37.8  -37.8  -22.7
